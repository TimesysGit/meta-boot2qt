RDEPENDS_${PN}_remove_tegra-t18x = "\
libgbm-dev \
"

