FILESEXTRAPATHS_prepend_tegra-t18x := "${THISDIR}/${PN}:"
