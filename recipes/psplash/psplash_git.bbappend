FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SPLASH_IMAGES = "file://qt.png;outsuffix=default"

