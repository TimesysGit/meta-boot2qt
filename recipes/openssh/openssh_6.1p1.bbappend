export libexecdir="/usr/libexec"

