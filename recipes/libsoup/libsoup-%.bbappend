DEPENDS += "glib-networking"
BBCLASSEXTEND = "native nativesdk"
