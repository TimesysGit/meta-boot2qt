DEPENDS_remove = "virtual/libgl libglu"
