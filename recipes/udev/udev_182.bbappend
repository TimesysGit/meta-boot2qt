FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += "file://0001-support-multitouch-screens.patch"

