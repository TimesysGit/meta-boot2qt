PROVIDES = "virtual/libgl virtual/libgles1 virtual/libgles2 virtual/egl"
