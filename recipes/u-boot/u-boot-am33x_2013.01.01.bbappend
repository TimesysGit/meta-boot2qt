FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"
SRC_URI += " \
        file://0001-am335x-evm-disable-console-cursor-blinking.patch \
        "
