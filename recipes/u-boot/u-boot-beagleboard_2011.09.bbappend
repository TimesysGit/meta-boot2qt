FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " \
        file://0001-beagle-change-default-kernel-args.patch \
        "
