FILESEXTRAPATHS_prepend := "${THISDIR}/${MACHINE}:"

COMPATIBLE_MACHINE = "(nitrogen6x|nitrogen6x-lite|wandboard-dual|wandboard-quad)"
