require recipes-qt/qt5/qt5.inc
